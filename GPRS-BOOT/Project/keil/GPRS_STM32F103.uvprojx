# Keil uVision project GPRS_STM32F103.uvprojx, settings and files
target GPRS_STM32F103_Code (ARM-ADS)
  device: STM32F103VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: GPRS_STM32F103 +hex
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: ..\..\Code\App;..\..\Code\Driver;..\..\Code\Driver\CMSIS\Core\CM3;..\..\Code\Driver\STM32F10x_StdPeriph_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group App
    ../../Code/App/: main.cpp App.cpp App.h CCLI.cpp CCLI.h CDownLoadManagement.cpp CDownLoadManagement.h CFlash.cpp CFlash.h MsgFrame.cpp JacTypeDef.h IAPprotocol.h IAPprotocol.cpp CFlashStm32F10x.cpp CFlashStm32F10x.h
  group Driver
    ../../Code/Driver/: usart.c UartDriver.cpp fastMalloc.cpp stm32f10x_it.c BSP.c Regtarge.c Cclock.cpp Cclock.h
    ../../Code/Driver/CMSIS/Core/CM3/: core_cm3.c system_stm32f10x.c
    ../../Code/Driver/CMSIS/Core/CM3/startup/arm/: startup_stm32f10x_hd.s
    ../../Code/Driver/STM32F10x_StdPeriph_Driver/src/: misc.c
  group STDPERIPH_DRIVER
    ../../Code/Driver/STM32F10x_StdPeriph_Driver/src/: stm32f10x_iwdg.c stm32f10x_dma.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_fsmc.c stm32f10x_exti.c stm32f10x_pwr.c
