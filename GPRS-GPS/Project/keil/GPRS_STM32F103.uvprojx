# Keil uVision project GPRS_STM32F103.uvprojx, settings and files
target GPRS_STM32F103_Code (ARM-ADS)
  device: STM32F103VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: GPRS_STM32F103 +hex
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: ..\..\Code\App;..\..\Code\Driver;..\..\Code\uos_ii\Ports;..\..\Code\Driver\CMSIS\Core\CM3;..\..\Code\Driver\STM32F10x_StdPeriph_Driver\inc;..\..\Code\DataLink;..\..\Code\USER;..\..\Code\Driver\NANDFLASH;..\..\Code\Adc;..\..\Code\TimeUtil
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ../../Code/Driver/: main.cpp stm32f10x_it.c
  group ucos_ii
    ../../Code/uos_ii/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
    ../../Code/uos_ii/Ports/: os_cpu_c.c os_dbg.c os_cpu_a.asm os_cfg.h os_cpu.h ucos_ii.h
  group STDPERIPH_DRIVER
    ../../Code/Driver/CMSIS/Core/CM3/: system_stm32f10x.c
    ../../Code/Driver/CMSIS/Core/CM3/startup/arm/: startup_stm32f10x_hd.s
    ../../Code/Driver/STM32F10x_StdPeriph_Driver/src/: stm32f10x_adc.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_pwr.c stm32f10x_sdio.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c stm32f10x_rcc.c
