# Keil uVision project ANO_Settler.uvprojx, settings and files
target ANO_Settler (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ANO_Settler +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: .\ANO_Settler;.\Driver;.\STM32_LIB\CMSIS;.\STM32_LIB\LIB\inc;.\USB_hid;.\USB_library
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group ANO_Settler
    ./ANO_Settler/: include.h main.c ANO_Config.h loop.c loop.h ANO_CTRL.c ANO_CTRL.h ANO_Init.c ANO_Init.h ANO_Data.c ANO_Data.h ANO_PID.c ANO_PID.h filter.c filter.h ANO_IMU.c ANO_IMU.h ANO_Param.c ANO_Param.h ANO_Data_Transfer.c ANO_Data_Transfer.h ANO_RC.c ANO_RC.h
  group Driver
    ./Driver/: ANO_Drv_ADC.c ANO_Drv_ADC.h ANO_Drv_BKP.c ANO_Drv_BKP.h ANO_Drv_Hid.c ANO_Drv_Hid.h ANO_Drv_LED.c ANO_Drv_LED.h ANO_Drv_MPU6050.c ANO_Drv_MPU6050.h ANO_Drv_Nrf24l01.c ANO_Drv_Nrf24l01.h ANO_Drv_SPI.c ANO_Drv_SPI.h ANO_Drv_Uart.c ANO_Drv_Uart.h ANO_Drv_Uart3.c ANO_Drv_Uart3.h stm32f10x_it.c stm32f10x_it.h bsp_SysTick.c bsp_SysTick.h i2c_soft.c i2c_soft.h mymath.c mymath.h time.c time.h ANO_Motor.c ANO_Motor.h ANO_Drv_Flash.c ANO_Drv_Flash.h ANO_Esp8266.c ANO_Esp8266.h
  group STM32_LIB
    ./STM32_LIB/CMSIS/: stm32f10x.h core_cm3.c system_stm32f10x.c startup_stm32f10x_md.s
    ./STM32_LIB/LIB/inc/: stm32f10x_conf.h
    ./STM32_LIB/LIB/src/: misc.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
  group USB_LIB
    ./USB_library/: usb_core.c usb_core.h usb_def.h usb_init.c usb_init.h usb_int.c usb_int.h usb_lib.h usb_mem.c usb_mem.h usb_regs.c usb_regs.h usb_type.h
  group USB_HID
    ./USB_hid/: usb_conf.h usb_config.c usb_config.h usb_desc.c usb_desc.h usb_endp.c usb_istr.c usb_istr.h usb_prop.c usb_prop.h usb_pwr.c usb_pwr.h
  group DOC
    ./doc/: record.txt txt.txt
